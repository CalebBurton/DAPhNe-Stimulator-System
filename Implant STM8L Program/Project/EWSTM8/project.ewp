# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Implant STM8L Program\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver/inc
    ../inc/: private_functions.h stm8l15x_it.h
    ../../STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_gpio.h stm8l15x_pwr.h stm8l15x_rtc.h stm8l15x_tim2.h stm8l15x_tim4.h
  group STM8L15x_StdPeriph_Driver/src
    ../src/: private_functions.c
    ../../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim4.c
  group User/inc
    ../inc/: stm8l15x_conf.h
  group User/src
    ../src/: main.c stm8l15x_it.c
