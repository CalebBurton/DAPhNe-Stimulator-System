<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\inc\stm8l15x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\inc\stm8l15x_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\inc\stm8l15x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\inc\stm8l15x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\inc\stm8l15x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\inc\stm8l15x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\inc\stm8l15x_lcd.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_lcd.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\inc\delay.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\discover_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\discover_functions.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\I2C_M24LR04E-R.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm8l15x_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm8l15x_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\vcc_measure.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\src\delay.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\discover_functions.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\eeprom.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\I2C_M24LR04E-R.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\stm8l15x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\vcc_measure.c</name>
      </file>
    </group>
  </group>
</project>


