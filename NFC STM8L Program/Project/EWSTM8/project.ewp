# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\NFC STM8L Program\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver/inc
    ../../STM8L15x_StdPeriph_Driver/inc/: stm8l15x_adc.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_lcd.h
  group STM8L15x_StdPeriph_Driver/src
    ../../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_lcd.c
  group User/inc
    ../inc/: delay.h discover_board.h discover_functions.h I2C_M24LR04E-R.h misc.h stm8l15x_conf.h stm8l15x_it.h vcc_measure.h
  group User/src
    ../src/: delay.c discover_functions.c eeprom.c I2C_M24LR04E-R.c main.c misc.c stm8l15x_it.c vcc_measure.c
