# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x300
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Implant STM8L Program NFC+Pulse\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Implant STM8L Program NFC+Pulse\M24LR04E-R_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group M24LR04E-R_Driver/inc
    ../../M24LR04E-R_Driver/inc/: I2C_M24LR04E-R.h
  group M24LR04E-R_Driver/src
    ../../M24LR04E-R_Driver/src/: I2C_M24LR04E-R.c
  group STM8L15x_StdPeriph_Driver/inc
    ../../STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_iwdg.h stm8l15x_pwr.h stm8l15x_rtc.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim4.h stm8l15x_wwdg.h
    ../inc/: stm8l15x_it.h
  group STM8L15x_StdPeriph_Driver/src
    ../../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_wwdg.c
  group User/inc
    ../inc/: daphne_hardware_config.h private_functions.h
  group User/src
    ../src/: daphne_hardware_config.c main.c private_functions.c stm8l15x_it.c
